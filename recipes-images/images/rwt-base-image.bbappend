CORE_IMAGE_EXTRA_INSTALL += "\
     misc-gether-files \
     usbc-helper \
     pciutils \
"
